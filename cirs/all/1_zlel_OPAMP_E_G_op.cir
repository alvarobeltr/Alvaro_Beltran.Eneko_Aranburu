A_10 1 2 3 0 0 0 0 0
V_10 1 0 0 0 10 0 0 0
e_40 2 0 0 0 4E3 0 0 r_10
r_10 3 5 0 0 1e3 0 0 0
r_20 5 4 0 0 2e3 0 0 0
r_30 4 2 0 0 3e3 0 0 0
A_20 0 5 4 0 0 0 0 0
.op 0 0 0 0 0 0 0 0
