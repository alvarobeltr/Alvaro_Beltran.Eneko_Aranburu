V_in  1 0 0 0  15 0 0    0
V_cc  4 0 0 0  15 0 0    0
K_1   3 2 0 0  0.6 500 100	0
R_B   1 2 0 0  100e3 0 0		0
R_C   3 4 0 0  500 0 0		0
.pr  0 0 0 0  0 0 0		0
.op  0 0 0 0  0 0 0		0
.dc  0 0 0 0  15 16 1e-1	V_in
