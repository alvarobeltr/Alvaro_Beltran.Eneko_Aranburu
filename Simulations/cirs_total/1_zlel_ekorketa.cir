r_01 2 1 0 0 1e3 0 0 0
R_02 0 2 0 0 2e3 0 0 0
v_in 1 0 0 0 3 0 0 0
R_03 2 3 0 0 200 0 0 0
i_01 0 3 0 0 -1e-3 0 0 0
r_04 2 4 0 0 2.5e3 0 0 0
f_01 4 5 0 0 4 0 0 R_01
r_out 5 0 0 0 10e3 0 0 0
.dc 0 0 0 0 3 36 3 v_in
