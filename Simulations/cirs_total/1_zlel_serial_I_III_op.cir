I_1 0 1 0 0 10 0 0 0
I_2 1 2 0 0 10 0 0 0
R_1 2 0 0 0 1e3 0 0 0
.op 0 0 0 0 0 0 0 0
