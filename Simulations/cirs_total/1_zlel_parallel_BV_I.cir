V_1 1 0 0 0 10 0 0 0
B_2 1 0 0 0 5 0.05 0 0
R_1 1 0 0 0 0 0 1e3 0
.op 0 0 0 0 0 0 0 0
