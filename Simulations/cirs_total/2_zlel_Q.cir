V_1 1 0 0 0 10 0 0 0
R_1 1 2 0 0 47e3 0 0 0
R_2 2 0 0 0 8.2e3 0 0 0
Q_1 3 2 4 0 7e-14 1e-13 100 0
R_C 1 3 0 0 3.3E3 0 0 0
R_E 4 0 0 0 560 0 0 0
.pr 0 0 0 0 0 0 0 0
.op 0 0 0 0 0 0 0 0
