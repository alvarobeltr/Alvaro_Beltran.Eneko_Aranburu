V_01  1 0 0 0  10 0 0 		0
R_01  1 2 0 0  2e3 0 0		0
D_01  2 0 0 0  1e-13 1 0		0
R_02  2 3 0 0  1e3 0 0		0
D_02  3 0 0 0  5E-13 0.9 0	0
.OP  0 0 0 0  0 0 0		0
.pr  0 0 0 0  0 0 0   0
