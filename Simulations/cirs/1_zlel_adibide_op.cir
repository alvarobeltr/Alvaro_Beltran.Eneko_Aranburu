I_01 0 1 0 0 1 0 0 0
r_10 1 0 0 0 4 0 0 0
r_13 1 3 0 0 1 0 0 0
h_21 2 1 0 0 4 0 0 r_30
r_20 2 0 0 0 1 0 0 0
g_23 3 2 0 0 2 0 0 r_13
r_30 3 0 0 0 4 0 0 0
r_34 3 4 0 0 2 0 0 0
v_40 4 0 0 0 10 0 0 0
.op 0 0 0 0 0 0 0 0
