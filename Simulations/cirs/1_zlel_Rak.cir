V_01 0 1 0 0 10 0 0 0
r_10 1 2 0 0 1e3 0 0 0
r_20 2 3 0 0 2e3 0 0 0
r_30 3 0 0 0 2e3 0 0 0
r_40 3 0 0 0 1e3 0 0 0
.op 0 0 0 0 0 0 0 0
.dc 0 0 0 0 3 36 3 V_01
