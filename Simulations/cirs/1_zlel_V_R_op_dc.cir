V_1 1 0 0 0 10 0 0 0
R_1 1 0 0 0 1e3 0 0 0
.op 0 0 0 0 0 0 0 0
.dc 0 0 0 0 0 4 1 V_1
